# Keil uVision project FM33FH0XX_Tester.uvprojx, settings and files
target Example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33FH02X FMSH
  pack: FMSH.FM33FH0XX_DFP.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33FH0xx_Tester +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: FM33FH0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc;..\Drivers\FM33FH0xx_FL_Driver\Inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33fh0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c lptim16.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33fh0xx.c
  group Drivers/FM33FH0xx_FL_Driver
    ../Drivers/FM33FH0xx_FL_Driver/Src/: fm33fh0xx_fl.c fm33fh0xx_fl_adc.c fm33fh0xx_fl_atim.c fm33fh0xx_fl_bstim16.c fm33fh0xx_fl_canfd.c fm33fh0xx_fl_clm.c fm33fh0xx_fl_cmu.c fm33fh0xx_fl_comp.c fm33fh0xx_fl_dac.c fm33fh0xx_fl_dma.c fm33fh0xx_fl_exti.c fm33fh0xx_fl_gpio.c fm33fh0xx_fl_iwdt.c fm33fh0xx_fl_lptim16.c fm33fh0xx_fl_lpuart.c fm33fh0xx_fl_pmu.c fm33fh0xx_fl_qspi.c fm33fh0xx_fl_rtc.c fm33fh0xx_fl_spi.c fm33fh0xx_fl_tau.c fm33fh0xx_fl_uart.c fm33fh0xx_fl_wwdt.c fm33fh0xx_fl_i2c.c fm33fh0xx_fl_crc.c fm33fh0xx_fl_sent.c fm33fh0xx_fl_svd.c fm33fh0xx_fl_flash.c
