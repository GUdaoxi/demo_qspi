# IAR project Example.ewp, settings and files
configuration Example (ARM, debug)
  General.OGChipSelectEditMenu: FM33FH05X FMSH FM33FH05X
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 29
  General.FPU2: 0
  ICCARM.CCDefines: FM33FH0XX; FM33LR0XX; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../Drivers/CMSIS/Inculde; ../Drivers/CMSIS/Device/FM/FM33xx/Include; ../MF-config/Inc; ../Inc; ../Drivers/FM33FH0xx_FL_Driver/Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Example.hex
  ILINK.IlinkOutputFile: Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/iar/: startup_fm33fh0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: axs15231.c fm25qxx_dual.c fm25qxx_qpi.c fm25qxx_quad.c fm25qxx_single.c main.c qspi.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33fh0xx.c
  group Drivers/FM33FH0xx_FL_Driver
    ../Drivers/FM33FH0xx_FL_Driver/Src/: fm33fh0xx_fl.c fm33fh0xx_fl_adc.c fm33fh0xx_fl_atim.c fm33fh0xx_fl_bstim16.c fm33fh0xx_fl_canfd.c fm33fh0xx_fl_clm.c fm33fh0xx_fl_cmu.c fm33fh0xx_fl_comp.c fm33fh0xx_fl_crc.c fm33fh0xx_fl_dac.c fm33fh0xx_fl_dma.c fm33fh0xx_fl_exti.c fm33fh0xx_fl_flash.c fm33fh0xx_fl_gpio.c fm33fh0xx_fl_i2c.c fm33fh0xx_fl_iwdt.c fm33fh0xx_fl_lptim16.c fm33fh0xx_fl_lpuart.c fm33fh0xx_fl_pmu.c fm33fh0xx_fl_qspi.c fm33fh0xx_fl_rtc.c fm33fh0xx_fl_sent.c fm33fh0xx_fl_spi.c fm33fh0xx_fl_svd.c fm33fh0xx_fl_tau.c fm33fh0xx_fl_uart.c fm33fh0xx_fl_wwdt.c
